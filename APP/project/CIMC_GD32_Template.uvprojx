# Keil uVision project CIMC_GD32_Template.uvprojx, settings and files
target CIMC_GD32_Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08011000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CIMC_GD32_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,APP_IMAGE
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HeaderFiles;..\Function;..\CMSIS\GD\GD32F4xx\Include;..\Driver\UART;..\Driver\IIC;..\Driver\OLED;..\Driver\Flash;..\Driver\RTC;..\Driver\LED;..\Driver\Timer;..\Driver\ADC;..\Driver\System;..\Protocol;..\Function;..\HeaderFiles
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Driver
    ../Driver/ADC/: ADC.c Analog.c pt100_spi.c
    ../Driver/LED/: LED.c
    ../Driver/IIC/: myiic.c
    ../Driver/OLED/: OLED.c
    ../Driver/RTC/: RTC.c
    ../Driver/Flash/: SPI_FLASH.c
    ../Driver/System/: sys.c
    ../Driver/Timer/: Tim.c
    ../Driver/UART/: RS485.c
  group Protocol
    ../Protocol/: Protocol.c
  group Function
    ../Function/: Function.c fun.c AppService.c
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h Head.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_dac.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c
  group Startup
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
software components: CMSIS:CORE 5.1.1
